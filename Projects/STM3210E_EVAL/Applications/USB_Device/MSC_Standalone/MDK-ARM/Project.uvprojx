# Keil uVision project Project.uvprojx, settings and files
target STM3210E_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM3210E_EVAL;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/User
    ../Src/: usbd_desc.c main.c stm32f1xx_it.c usbd_storage.c usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_pcd.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_sd.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/STM3210E_EVAL
    ../../../../../../Drivers/BSP/STM3210E_EVAL/: stm3210e_eval.c stm3210e_eval_sd.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc.c usbd_msc_scsi.c usbd_msc_data.c
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
software components: CMSIS:CORE 4.1.0
