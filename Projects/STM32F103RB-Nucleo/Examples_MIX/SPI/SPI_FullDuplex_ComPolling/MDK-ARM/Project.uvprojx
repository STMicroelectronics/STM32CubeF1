# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103RB-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F1xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_LL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
  group Drivers/BSP/STM32F1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c
  group Example/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
