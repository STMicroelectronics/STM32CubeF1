# IAR project Project.ewp, settings and files
configuration STM3210C_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F107xC; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM3210C_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STemWin\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210C_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: BASIC_HelloWorld.c main.c stm32f1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/ili9320
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Drivers/BSP/STM3210C_EVAL
    ../../../../../../Drivers/BSP/STM3210C_EVAL/: stm3210c_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf_stm3210c_eval.c LCDConf_stm32l10c_eval.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM3_wc32.a
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
