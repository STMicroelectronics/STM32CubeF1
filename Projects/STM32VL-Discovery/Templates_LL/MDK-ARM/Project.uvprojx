# Keil uVision project Project.uvprojx, settings and files
target STM32VL-Discovery (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VL-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F100xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../Drivers/STM32F1xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f100xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32f1xx_LL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_exti.c stm32f1xx_ll_usart.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_tim.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_i2c.c stm32f1xx_ll_spi.c stm32f1xx_ll_dac.c stm32f1xx_ll_crc.c stm32f1xx_ll_utils.c stm32f1xx_ll_rtc.c
  group Example/User
    ../Src/: main.c stm32f1xx_it.c
software components: CMSIS:CORE 4.3.0
