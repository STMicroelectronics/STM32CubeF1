# Keil uVision project Project.uvprojx, settings and files
target STM32VL-Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F100VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VL-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F100xB,USE_STM32VL_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32VL-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../: readme.txt
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c
  group Drivers/BSP/STM32VL-Discovery
    ../../../../../../Drivers/BSP/STM32VL-Discovery/: stm32vl_discovery.c
  group Example/MDK-ARM
    ./: startup_stm32f100xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: main.c stm32f1xx_it.c
    ../../../../../STM3210C_EVAL/Examples/HAL/HAL_TimeBase_TIM/Src/: stm32f1xx_hal_timebase_tim.c
software components: CMSIS:CORE 4.3.0
